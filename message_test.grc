<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_message_sink</key>
<param><key>id</key><value>blocks_message_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>dont_block</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_termsink</key>
<param><key>id</key><value>wxgui_termsink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>packet_len</key><value>1</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/matt/sandbox/trig.dat</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>sandbox_msg_src</key>
<param><key>id</key><value>sandbox_msg_src_0</value></param>
</block>
<block>
<key>sandbox_msg_sink</key>
<param><key>id</key><value>sandbox_msg_sink_0</value></param>
</block>
<block>
<key>sandbox_msg_proc</key>
<param><key>id</key><value>sandbox_msg_proc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>sandbox_msg_div</key>
<param><key>id</key><value>sandbox_msg_div_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sandbox_msg_proc_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_message_sink_0</source_block_id><sink_block_id>wxgui_termsink_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>blocks_message_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_1</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>sandbox_msg_src_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>sandbox_msg_src_0</source_block_id><sink_block_id>sandbox_msg_proc_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>sandbox_msg_proc_0</source_block_id><sink_block_id>sandbox_msg_sink_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>sandbox_msg_src_0</source_block_id><sink_block_id>sandbox_msg_div_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>sandbox_msg_div_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>sandbox_msg_div_0</source_block_id><sink_block_id>sandbox_msg_sink_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
</flow_graph>
